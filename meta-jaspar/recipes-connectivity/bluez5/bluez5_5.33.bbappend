PR = "r2"
FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append = "file://compat.patch"


