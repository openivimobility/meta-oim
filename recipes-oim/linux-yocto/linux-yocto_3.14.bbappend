
PR="r0"
FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://wlan.cfg"
LINUX_VERSION_EXTENSION ?= "-ats"

